# Keil uVision project Porject.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CMS32F033 Cmsemicon
  pack: Cmsemicon.CMS32-Series.1.0.3
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: boot +hex
  AfterMake: fromelf --bin --output Objects\boot.bin Objects\boot.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Libary\CMSIS\Include;.\Libary\Device\CMS32F033\Include;.\Libary\StdDriver\inc;.\USER;.\Libary\StdDriver\inc
  memory RVCT4: ROM 0x7000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group New Group
    ./USER/: main.c user.c system_cms32f033x.c startup_cms32f033x.s
    ./Libary/StdDriver/src/: system.c
